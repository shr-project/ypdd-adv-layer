require kmod-minnow-max.inc

MODDIR = "i2c"
