require kmod-minnow-max.inc

MODDIR = "ika"
