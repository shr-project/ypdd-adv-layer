require kmod-minnow-max.inc

MODDIR = "mpu6050"
